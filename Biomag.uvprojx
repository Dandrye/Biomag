# Keil uVision project Biomag.uvprojx, settings and files
target 1986BE91T (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Biomag +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _USE_WRITE
  c include: .\Header_Files;.\PetitFatFs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source_Files
    ./Source_Files/: date_time.c main.c MDR32F9Qx_it.c init.c meas.c sd_card.c adc.c menu.c dspl.c usb.c
  group Header_Files
    ./Header_Files/: date_time.h def.h MDR32F9Qx_it.h menu.h init.h meas.h sd_card.h adc.h dspl.h usb.h
  group PetitFatFs
    ./PetitFatFs/: diskio.h integer.h mmc.c pff.c pff.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.3, Drivers:ADC 2.0.3, Drivers:BKP 2.0.3, Drivers:I2C 2.0.3, Drivers:IWDG 2.0.3, Drivers:PORT 2.0.3, Drivers:POWER 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:TIMER 2.0.3, Drivers:USB Library 2.0.3, Drivers:USB 2.0.3
